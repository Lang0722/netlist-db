r1 1 0 1k
.end
r2 1 0 2k
