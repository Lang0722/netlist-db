R1 1 0 1
v1 1 0 1
r2 1 0 2
.op
.end
